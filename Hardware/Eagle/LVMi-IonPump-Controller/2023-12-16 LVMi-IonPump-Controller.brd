# Repository auomoto/LVMi-IonPump-Controller

File README.md:

# LVMi-IonPump-Controller
 Readout for Modion Pump

## EAGLE design Hardware/Eagle/LVMi-IonPump-Controller/2023-12-16 LVMi-IonPump-Controller.brd

Parts:
C1, C2, C3: 4.7uF 50V; C0805
C4, C5, C6: 0.22uF 50V; C0805
C7, C8, C9, C19, C20, C21: 1uF; C0805
C10, C11, C12: 1uF 50V; C0805
C13, C14, C15: 0.1uF 50V; C0805
C16, C17, C18: 0.1uF; C0805
D1: PMEG6030EVPX; DIO_PMEG6030EVPX
J1: CUI PJ-102AH; PJ-102AH
J2, J3, J4: MOLEX-22112022; 1X02-MOLEX-22112022
J5, J6, J7: MOLEX 0022112042; 1X04-MOLEX-22112042
J8: PHOENIX_1X16HDR_1985331; 1985331
L1, L2, L3: 6.8uH WURTH-744032006; WURTH-1210-INDUCTOR
PS1, PS2, PS3: RECOM-RS6-2415S; CONV_RS6-2415S
PS4: TSR_1-2450; CONV_TSR_1-2450
Q1, Q2, Q3: AQY211G2S; SOP4_PAN
R1, R2, R3: 47K Opt; R0805
R4, R5, R6: 1K; R0805
R7, R8, R9: 0R; R0805
TP1, TP2: GND; TP5000-TESTPOINT-BLK
TP3: +24V; TP5000-TESTPOINT-BLK
TP4: +5V; TP5000-TESTPOINT-BLK
TP5: A-ON; TP5000-TESTPOINT-BLK
TP6: B-ON; TP5000-TESTPOINT-BLK
TP7: C-ON; TP5000-TESTPOINT-BLK
U1, U2, U3: ISO224ADWVR; DWV8_TEX

Connections:
+5V: C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, J8.3, J8.8, PS4.3 (+VOUT), TP4.P$1, U1.8 (VDD2), U2.8 (VDD2), U3.8 (VDD2)
+24V: D1.2 (A), J1.PWR
+24V-PROT: C1.1, C2.1, C3.1, D1.1 (K), J8.2, L1.1, L2.1, L3.1, PS4.1 (+VIN), TP3.P$1
+VIN-A: L1.2, PS1.2 (+VIN)
+VIN-B: L2.2, PS2.2 (+VIN)
+VIN-C: L3.2, PS3.2 (+VIN)
+VOUT-A: J2.1, PS1.6 (+VOUT)
+VOUT-B: J3.1, PS2.6 (+VOUT)
+VOUT-C: J4.1, PS3.6 (+VOUT)
+VOUT-SW-A: J2.2, Q1.4
+VOUT-SW-B: J3.2, Q2.4
+VOUT-SW-C: J4.2, Q3.4
A-ON: J8.14, R7.2, TP5.P$1
B-ON: J8.10, R8.2, TP6.P$1
C-ON: J8.5, R9.2, TP7.P$1
GND: C1.2, C2.2, C3.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, J1.GND, J8.1, J8.4, J8.9, J8.13, PS1.1 (-VIN), PS2.1 (-VIN), PS3.1 (-VIN), PS4.2 (GND), Q1.2, Q2.2, Q3.2, TP1.P$1, TP2.P$1, U1.5 (GND2), U2.5 (GND2), U3.5 (GND2)
GND-A: C4.2, C7.2, C10.2, C13.2, J5.2, PS1.7 (-VOUT), R1.2, U1.4 (GND1)
GND-B: C5.2, C8.2, C11.2, C14.2, J6.2, PS2.7 (-VOUT), R2.2, U2.4 (GND1)
GND-C: C6.2, C9.2, C12.2, C15.2, J7.2, PS3.7 (-VOUT), R3.2, U3.4 (GND1)
IN-A: C7.1, R4.1, U1.2 (IN)
IN-B: C8.1, R5.1, U2.2 (IN)
IN-C: C9.1, R6.1, U3.2 (IN)
unnamed: Q3.1, R9.1
unnamed: Q1.1, R7.1
unnamed: Q2.1, R8.1
unnamed: PS3.5 (TRIM), R3.1
unnamed: PS2.5 (TRIM), R2.1
unnamed: PS1.5 (TRIM), R1.1
OUTN-A: J8.15, U1.6 (OUTN)
OUTN-B: J8.11, U2.6 (OUTN)
OUTN-C: J8.6, U3.6 (OUTN)
OUTP-A: J8.16, U1.7 (OUTP)
OUTP-B: J8.12, U2.7 (OUTP)
OUTP-C: J8.7, U3.7 (OUTP)
SIG-IP-A: J5.1, R4.2
SIG-IP-B: J6.1, R5.2
SIG-IP-C: J7.1, R6.2
VCAP-A: C4.1, U1.1 (VCAP)
VCAP-B: C5.1, U2.1 (VCAP)
VCAP-C: C6.1, U3.1 (VCAP)
VDD1-A: C10.1, C13.1, J5.3, U1.3 (VDD1)
VDD1-B: C11.1, C14.1, J6.3, U2.3 (VDD1)
VDD1-C: C12.1, C15.1, J7.3, U3.3 (VDD1)
VOUT-RL-A: J5.4, Q1.3
VOUT-RL-B: J6.4, Q2.3
VOUT-RL-C: J7.4, Q3.3

Notes on the sheet:
Pins 3 & 4 are shorted at the connector

Board: 2 copper layers, 127.0 x 63.5 mm, 59 parts (0 on the bottom side), 46 nets.

## Commit log

2024-01-11 Catch up
2024-01-11 Upload hardware
2024-01-11 Remove outdated files

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2018 Accelerated Designs. All rights reserved
COPYRIGHT: Copyright (C) 2023 Ultra Librarian. All rights reserved.
